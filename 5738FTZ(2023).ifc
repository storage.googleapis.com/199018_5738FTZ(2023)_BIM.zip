Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-06-23T19:42:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 23 19:42:54 2023 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\a8b81a45-bc04-4638-93d5-d3fb21c8155a\62c67b25-f6d5-4a95-a2f6-9374dd8cc066\ifc * Database version: 5507 * Database creation date: Fri Jun 23 19:42:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 23 19:42:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 23 19:42:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 5738FTZ Kitchen faucet, 230/9 V, Bluetooth, 5738FTZ(2023):5738FTZ Kitchen faucet, 230/9 V, Bluetooth:51381
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 261.5 mm; NominalHeight: 338.336 mm; NominalWidth: 53.9562 mm
Type - Electrical - Bluetooth: 5.x (D060576); Electrical Connection: 230 / 9 V; Operating Voltage: 9 V; Protection Class: IP 55 / transformer IP 20
Type - General - Author: BIMStone; BIMObjectName: 5738FTZ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150102059; EMC Directive: 2014/53/EU , 2011/65/EU; EN Standard: EN 817, EN 15091; ETIM Class Number: EC011431 Kitchen mixing tap; Noise Class: I (ISO 3822); NRF Number: 4200623; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/5738FTZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/5738FTZ; URL WEEE: http://static.oras.com/WEEE/5738FTZ; VVS Number: 704248404
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5738FTZ; 3D View: https://static.oras.com/AR/5738FTZ; Catalog Drawing URL: http://static.oras.com/catdrw/5738FTZ; Dimension Drawing URL: http://static.oras.com/dimdrw/5738FTZ; FDV Document URL: http://www.oras.com/datasheet/5738FTZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5738FTZ; Group: Kitchen faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/5738FTZ; Interactive AR View URL: https://static.oras.com/AR/5738FTZ; Long Marketing: Care Hybrid series is giving you a whole new modern design to fit into any kitchen. Lever can easily be moved by using the backside of the hand and with our intelligent touchless functions build into same faucet it also supports hygiene operation without any touch needed.; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/5738FTZ; Model: 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; Name_en: 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5738FTZ; Product Family: Oras Care Hybrid; Product Image URL: http://static.oras.com/image/5738FTZ; Product URL: http://static.oras.com/5738FTZ; Technical DataSheet URL: http://www.oras.com/datasheet/5738FTZ/en; Type Name: 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: Laminar stream; Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: ;Solenoid valve;Power supply; Flow Rate At 300kPa: 0.00600349 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 10 s(1 - 1800 s); Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 02ls: 195000 Pa; Spout Projection: 178 mm; Spout Swivel Range: 120° (80°/40°); Spout Type: Swivel spout;Swivel range limiting option;Profile construction; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5738FTZ(2023); Features: Hybrid;Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5738FTZ; Name: 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 55x260x340 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.121965 m2; Volume: 0.00478235 m3
Identity Data - Mark: 21
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5738FTZ(2023): 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; Family and Type: 5738FTZ(2023): 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5738FTZ(2023): 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; Type Id: 5738FTZ(2023): 5738FTZ Kitchen faucet, 230/9 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
